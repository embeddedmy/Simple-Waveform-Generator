# Keil uVision project Simple_Waveform_Generator.uvprojx, settings and files
target simple_waveform_generator (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Simple_Waveform_Generator
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group sources
    ./: main.c dac.c timer.c WaveGen.c dma.c
  group includes
    ./: dac.h timer.h WaveGen.h dma.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.5.0
